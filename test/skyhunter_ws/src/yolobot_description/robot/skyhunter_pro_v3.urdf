Commit message: fox lidar a

File: test/skyhunter_ws/src/yolobot_description/robot/skyhunter_pro_v3.urdf (robot description, URDF)
Before this commit: robot skyhunter_pro_v3, 10 links, 9 joints
Links:
- link chassis_link: geometry collision box size=0.8 0.5 0.15; visual box size=0.8 0.5 0.15
